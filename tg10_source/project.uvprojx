# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B0VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output firmware.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: LFS_CONFIG=lfs_config.h, STM32H7B0xx, USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;rt-thread\components\net\at\include;packages\LuatOS-latest\luat\packages\lua-cjson;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\extension;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m7;packages\crc32;packages\crclib-v1.02\inc;rt-thread\components\drivers\hwcrypto;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;board;board\port;board\CubeMX_Config\Core\Inc;libraries\drivers;libraries\drivers\include;libraries\drivers\include\config;packages\LuatOS-latest\luat\packages\u8g2;packages\LuatOS-latest\components\network\libmqtt;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\dfs\filesystems\romfs;rt-thread\components\finsh;packages\FlashDB-v1.1.2\inc;packages\fsm;packages\hashmap;packages\LuatOS-latest\luat\packages\iconv;.;rt-thread\include;packages\littlefs-latest;packages\lora_radio_driver-v1.4.3\lora-radio;packages\lora_radio_driver-v1.4.3\lora-radio\include;packages\lora_radio_driver-v1.4.3\lora-radio\common;packages\lora_radio_driver-v1.4.3\ports;packages\lora_radio_driver-v1.4.3\ports\lora-module\inc;packages\lora_radio_driver-v1.4.3\samples;packages\LuatOS-latest\lua\include;packages\LuatOS-latest\luat\vfs;packages\LuatOS-latest\luat\weak;packages\LuatOS-latest\rt-thread\port;packages\LuatOS-latest\rt-thread\lib;packages\lwgps-v1.1.0;packages\lwgps-v1.1.0\lwgps\lwgps\src\include;packages\lwgps-v1.1.0\lwgps\lwgps\src\include\lwgps;rt-thread\components\net\lwip\lwip-2.1.2\src\include;rt-thread\components\net\lwip\lwip-2.1.2\src\include\netif;rt-thread\components\net\lwip\lwip-2.1.2\src\netif\ppp;rt-thread\components\net\lwip\port;packages\mem_sandbox-latest;packages\mesh;packages\mesh\mesh_tm;packages\minizip-latest;packages\LuatOS-latest\luat\packages\minmea;packages\LuatOS-latest\luat\modules;packages\LuatOS-latest\luat\include;packages\LuatOS-latest\luat\packages\minmea;packages\LuatOS-latest\luat\packages\lua-cjson;packages\mymqtt-latest\MQTTPacket\src;packages\mymqtt-latest\MQTTClient-C;packages\netutils-latest\ntp;packages\netutils-latest\tftp;.;packages\optparse-latest;packages\beep-v1.1.0;packages\easyblink-v2.0.1;libraries\samples;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\io\termios;rt-thread\components\libc\posix\ipc;packages\powerbus;packages\ppp_device-v1.1.0\inc;packages\LuatOS-latest\luat\packages\qrcode;rt-thread\components\drivers\usb\usbdevice;rt-thread\components\net\netdev\include;rt-thread\components\net\sal\include;rt-thread\components\net\sal\include\socket;rt-thread\components\net\sal\impl;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\net\sal\include\socket\sys_socket;libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;libraries\STM32H7xx_HAL\CMSIS\Include;packages\tinycrypt-latest\include;applications\drv;applications\lua;rt-thread\components\utilities\ulog;rt-thread\components\utilities\ymodem;packages\vconsole-v1.0.0;.;packages\webclient-v2.2.0\inc;packages\wiznet-v2.0.0\inc;packages\wiznet-v2.0.0\ioLibrary;packages\wiznet-v2.0.0\ioLibrary\Ethernet;packages\wiznet-v2.0.0\ioLibrary\Internet;packages\zlib-v1.2.3\inc
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Applications
    applications/: main.c
  group AT
    rt-thread/components/net/at/src/: at_utils.c at_cli.c at_client.c
  group cjson
    packages/LuatOS-latest/luat/packages/lua-cjson/: fpconv.c strbuf.c lua_cjson.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c backtrace.c showmem.c
    rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group crc32
    packages/crc32/: crc32.c
  group crclib
    packages/crclib-v1.02/src/: crc8_ex.c crc16_ex.c crc8.c crc32_ex.c crc16.c crc16_ex_sample.c crc32.c
  group DeviceDrivers
    rt-thread/components/drivers/hwcrypto/: hw_gcm.c hw_hash.c hw_rng.c hw_crc.c hw_symmetric.c hw_bignum.c hwcrypto.c
    rt-thread/components/drivers/ipc/: waitqueue.c dataqueue.c pipe.c workqueue.c completion.c ringblk_buf.c ringbuffer.c
    rt-thread/components/drivers/misc/: adc.c pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c alarm.c
    rt-thread/components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    rt-thread/components/drivers/watchdog/: watchdog.c
  group Drivers
    board/: drv_mpu.c board.c
    board/port/: fal_flash_ospi_mem_port.c filesystem.c
    board/CubeMX_Config/Core/Src/: stm32h7xx_hal_msp.c
    libraries/drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_crypto.c drv_adc.c drv_usbd.c drv_wdt.c drv_wlan.c drv_sdio.c drv_lcd.c drv_rtc.c drv_usart.c drv_common.c drv_flash.c
  group emqtt_lua
    packages/LuatOS-latest/components/network/libmqtt/: luat_lib_mqtt.c
  group Fal
    rt-thread/components/fal/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
  group Filesystem
    rt-thread/components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: ffunicode.c ff.c dfs_elm.c
    rt-thread/components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_file.c cmd.c
  group FlashDB
    packages/FlashDB-v1.1.2/src/: fdb_cmd.c fdb_utils.c fdb_kvdb.c fdb_tsdb.c fdb.c fdb_file.c
  group fsm
    packages/fsm/: fsm.c fsm_port.c
  group hashmap
    packages/hashmap/: hashmap.c
  group iconv
    packages/LuatOS-latest/luat/packages/iconv/: ucs2_to_gb2312.c utf8_to_ucs2.c iconv.c gb2312_to_ucs2.c luat_lib_iconv.c
  group Kernel
    rt-thread/src/: device.c thread.c components.c clock.c mempool.c memheap.c object.c timer.c kservice.c scheduler.c idle.c irq.c ipc.c
  group littlefs
    packages/littlefs-latest/: dfs_lfs.c lfs_crc.c lfs.c lfs_util.c
  group lora-radio-driver
    packages/lora_radio_driver-v1.4.3/lora-radio/common/: lora-radio-timer.c
    packages/lora_radio_driver-v1.4.3/lora-radio/sx126x/: lora-radio-sx126x.c lora-spi-sx126x.c sx126x.c
  group lora-radio-driver/board
    packages/lora_radio_driver-v1.4.3/ports/lora-module/stm32_adapter/SX1268_LSD4RF-2R717N40/: sx1268-board.c
    packages/lora_radio_driver-v1.4.3/ports/lora-module/stm32_adapter/: lora-spi-board.c
  group lora-radio-driver/sample
    packages/lora_radio_driver-v1.4.3/samples/lora-radio-tester/: lora-radio-tester.c
  group Lua
    packages/LuatOS-latest/lua/src/: ltests.c lcode.c ldblib.c lzio.c lctype.c lapi.c lundump.c lbaselib.c loslib.c lstate.c rotable2.c ltable.c loadlib.c ldebug.c lparser.c lauxlib.c bget.c leiolib.c lopcodes.c linit.c lbitlib.c llex.c lgc.c ltablib.c lstrlib_exts.c lstrlib.c ldump.c lmathlib.c ldo.c liolib.c lmem.c lvm.c lutf8lib.c lcorolib.c luat_bget.c printf.c ltm.c rotable.c lobject.c lfunc.c lstring.c
  group luat_vfs
    packages/LuatOS-latest/luat/vfs/: luat_fs_luadb.c luat_inline_libs.c luat_inline_sys.c luat_fs_lfs2.c luat_vfs.c luat_luadb_inline_sys.c luat_fs_onefile.c luat_fs_posix.c luat_luadb_inline.c
  group luat_weak
    packages/LuatOS-latest/luat/weak/: luat_log_weak.c luat_fs_weak.c luat_malloc_weak.c
  group luatos_port
    packages/LuatOS-latest/rt-thread/port/: luatos.c luatos_romfs.c
  group luatos_rtt
    packages/LuatOS-latest/rt-thread/lib/: luat_http_rtt.c luat_spi_rtt.c luat_gpio_rtt.c luat_malloc_rtt.c luat_msgbus_rtt.c luat_adc_rtt.c luat_log_rtt.c luat_uart_rtt.c luat_fs_rtt.c luat_rtt_base.c luat_netclient_rtt.c luat_msh_rtt.c luat_crypto_rtt.c luat_timer_rtt.c luat_rtc_rtt.c luat_socket_rtt.c luat_luadb_rtt.c
  group lwgps
    packages/lwgps-v1.1.0/: lwgps2rtt.c
    packages/lwgps-v1.1.0/lwgps/lwgps/src/lwgps/: lwgps.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/ppp/polarssl/: arc4.c md5.c md4.c des.c sha1.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/ppp/: ccp.c lcp.c multilink.c pppol2tp.c ecp.c auth.c chap-new.c ppp.c chap-md5.c pppos.c ipcp.c utils.c mppe.c eap.c upap.c pppapi.c eui64.c magic.c pppoe.c ipv6cp.c demand.c fsm.c chap_ms.c pppcrypt.c vj.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/mqtt/: mqtt.c
    rt-thread/components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group lwip_lua
    packages/LuatOS-latest/components/network/lwip/binding/: luat_lib_lwip_mqtt.c luat_lib_lwip.c luat_lib_lwip_etcp.c luat_lib_lwip_tcp.c luat_lib_lwip_udp.c
  group mem_sandbox
    packages/mem_sandbox-latest/: mem_sandbox.c
  group Mesh
    packages/mesh/mesh_tm/: mesh_tm.c
    packages/mesh/: mesh.c mesh_app.c mesh_fun.c tiny_aes_fun.c mesh_radio.c mesh_radio2.c mesh_port.c
  group minizip
    packages/minizip-latest/: ioapi.c mztools.c minizip.c miniunz.c zip.c unzip.c
  group minmea
    packages/LuatOS-latest/luat/packages/minmea/: minmea.c luat_lib_libgnss.c
  group modules
    packages/LuatOS-latest/luat/modules/: luat_base.c luat_lib_rtc.c luat_lib_crypto.c crc.c luat_main.c luat_lib_ctiot.c luat_lib_adc.c luat_lib_timer.c luat_lib_zbuff.c luat_lib_socket.c luat_luat_bin.c luat_ota.c luat_lib_libcoap.c luat_lib_fs.c luat_lib_pack.c luat_lib_ir.c luat_irq.c luat_lib_sensor.c luat_lib_vmx.c luat_lib_log.c luat_lib_spi.c luat_lib_http.c luat_lib_dbg.c luat_lib_uart.c luat_sysp.c luat_lib_rtos.c luat_lib_sys_doc.c luat_lib_mqttcore.c luat_lib_gpio.c
  group my-mqtt
    packages/mymqtt-latest/MQTTPacket/src/: MQTTUnsubscribeClient.c MQTTDeserializePublish.c MQTTUnsubscribeServer.c MQTTPacket.c MQTTConnectClient.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTFormat.c MQTTConnectServer.c MQTTSubscribeServer.c
    packages/mymqtt-latest/MQTTClient-C/: mqtt_client.c
    packages/mymqtt-latest/samples/: mqtt_sample.c
  group NetUtils
    packages/netutils-latest/ntp/: ntp.c
    packages/netutils-latest/telnet/: telnet.c
    packages/netutils-latest/tftp/: tftp_xfer.c tftp_client.c tftp_port.c tftp_server.c
  group optparse
    packages/optparse-latest/: optparse.c
  group Packages
    packages/beep-v1.1.0/: beep.c
    packages/easyblink-v2.0.1/: easyblink.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: select.c poll.c
    rt-thread/components/libc/posix/io/stdio/: libc.c
    rt-thread/components/libc/posix/io/termios/: termios.c
  group PowerBus
    packages/powerbus/: power_bus.c power_fun.c packet_parser.c power_tm.c power_app.c
  group ppp_device
    packages/ppp_device-v1.1.0/class/: ppp_device_ec20.c
    packages/ppp_device-v1.1.0/src/: ppp_device.c ppp_chat.c ppp_netif.c
    packages/ppp_device-v1.1.0/samples/: ppp_sample.c
  group qrcode
    packages/LuatOS-latest/luat/packages/qrcode/: qrcode.c
  group rt_kprintf
    packages/rt_kprintf_threadsafe-latest/: rt_kprintf.c
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group rt_usbd
    rt-thread/components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev_ipaddr.c netdev.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_sockets.c net_netdb.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group STM32_HAL
    libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim.c stm32h7xx_hal_pcd.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_ll_usb.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_rtc.c stm32h7xx_hal_cortex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_usart.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_hash.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_qspi.c stm32h7xx_hal_pwr_ex.c
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h7b0xx.s
    libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group TinyCrypt
    packages/tinycrypt-latest/src/: tiny_sha2.c tiny_base64.c tiny_sha1.c tiny_aes.c tiny_md5.c
  group UserDrv
    applications/drv/: drv_uart_test.c drv_console.c drv_tm1650.c drv_ain.c drv_dio.c drv_param.c
  group UserLua
    applications/lua/: luat_lora.c luat_env.c luat_dio.c luat_gnss.c luat_aio.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
  group vconsole
    packages/vconsole-v1.0.0/: vconsole.c
  group vi
    packages/vi-latest/: vi.c vi_utils.c
  group WebClient
    packages/webclient-v2.2.0/samples/: webclient_shard_download_sample.c webclient_get_sample.c webclient_post_sample.c
    packages/webclient-v2.2.0/src/: webclient.c webclient_file.c
  group WIZnet
    packages/wiznet-v2.0.0/src/: wiz.c wiz_ping.c wiz_device.c wiz_af_inet.c wiz_socket.c
    packages/wiznet-v2.0.0/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    packages/wiznet-v2.0.0/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-v2.0.0/ioLibrary/Ethernet/W5500/: w5500.c
    packages/wiznet-v2.0.0/ioLibrary/Ethernet/: wizchip_socket.c wizchip_conf.c
  group zlib
    packages/zlib-v1.2.3/src/: compress.c trees.c crc32.c zutil.c inflate.c deflate.c adler32.c uncompr.c inftrees.c infback.c inffast.c
